SRC_URI += "file://user_2019-06-19-12-04-00.cfg \
            file://user_2019-06-19-14-31-00.cfg \
            file://user_2019-06-20-10-57-00.cfg \
            file://user_2019-06-20-11-21-00.cfg \
            file://user_2019-06-21-13-49-00.cfg \
            file://user_2019-08-05-14-39-00.cfg \
            file://user_2019-09-11-15-27-00.cfg \
            file://user_2019-09-11-15-58-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

