
YAML_SERIAL_CONSOLE_STDOUT_forcevariable = "ps7_uart_1"
YAML_SERIAL_CONSOLE_STDIN_forcevariable = "ps7_uart_1"
